# Repository doctea/usb_midi_clocker_hardware (continued)

## KiCad design _backups/usb_midi_clocker circuits.kicad_pcb (continued)

Board: 2 copper layers, 135.6 x 128.5 mm, 22 parts (14 on the bottom side), 58 nets.

## KiCad design expander_gate_output/bakcups/expander_gate_output.kicad_pcb

Board: 2 copper layers, 79.9 x 128.5 mm, 37 parts (1 on the bottom side), 36 nets.

Parts:
C1, C2: C_Small; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1, D2, D3, D4, D5, D6, D7, D8: LED; LED_D3.0mm
GATE_OUTPUT_EXPANDER1: 12 pin header; PinHeader_2x08_P2.54mm_Vertical
JACK1: Thonkiconn Renumberred
JACK2, JACK3, JACK4, JACK5, JACK6, JACK7, JACK8: fuzzySI_thonkiconn; Thonkiconn Renumberred
R1, R3, R5, R7, R9, R11, R13, R15: 47K; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
R2, R4, R6, R8, R10, R12, R14, R16: 1K; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
R_PULLDOWN1: R; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
U1: TXS0108EPW; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
+3V3: C1.2, GATE_OUTPUT_EXPANDER1.10, GATE_OUTPUT_EXPANDER1.12, U1.2 (VCCA)
+5V: C2.1, GATE_OUTPUT_EXPANDER1.6, GATE_OUTPUT_EXPANDER1.8, U1.19 (VCCB)
GATE_1: GATE_OUTPUT_EXPANDER1.1, U1.1 (A1)
GATE_2: GATE_OUTPUT_EXPANDER1.3, U1.3 (A2)
GATE_3: GATE_OUTPUT_EXPANDER1.5, U1.4 (A3)
GATE_4: GATE_OUTPUT_EXPANDER1.7, U1.5 (A4)
GATE_5: GATE_OUTPUT_EXPANDER1.9, U1.6 (A5)
GATE_6: GATE_OUTPUT_EXPANDER1.11, U1.7 (A6)
GATE_7: GATE_OUTPUT_EXPANDER1.13, U1.8 (A7)
GATE_8: GATE_OUTPUT_EXPANDER1.15, U1.9 (A8)
GND: C1.1, C2.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), GATE_OUTPUT_EXPANDER1.2, GATE_OUTPUT_EXPANDER1.4, JACK1.1, JACK2.1, JACK3.1, JACK4.1, JACK5.1, JACK6.1, JACK7.1, JACK8.1, R_PULLDOWN1.1, U1.11 (GND)
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R3.1
unnamed: D3.2 (A), R5.1
unnamed: D4.2 (A), R7.1
unnamed: D5.2 (A), R9.1
unnamed: D6.2 (A), R11.1
unnamed: D7.2 (A), R13.1
unnamed: D8.2 (A), R15.1
unnamed: JACK1.3, R2.1
unnamed: JACK2.3, R4.1
unnamed: JACK3.3, R6.1
unnamed: JACK4.3, R8.1
unnamed: JACK5.3, R10.1
unnamed: JACK6.3, R12.1
unnamed: JACK7.3, R14.1
unnamed: JACK8.3, R16.1
unnamed: R_PULLDOWN1.2, U1.10 (OE)
output_1: R1.2, R2.2, U1.20 (B1)
output_2: R3.2, R4.2, U1.18 (B2)
output_3: R5.2, R6.2, U1.17 (B3)
output_4: R7.2, R8.2, U1.16 (B4)
output_5: R9.2, R10.2, U1.15 (B5)
output_6: R11.2, R12.2, U1.14 (B6)
output_7: R13.2, R14.2, U1.13 (B7)
output_8: R15.2, R16.2, U1.12 (B8)

## Commit log

2023-06-07 tracked WIP
2023-06-07 laid out
2023-06-08 laid out some more
2023-06-09 rough layout of single midi expander
2023-06-09 further tweaks
2023-06-10 cleaned up schematic a little to add the front/backboard connection
2023-06-10 laid out quite nicely now i think
2023-06-10 put output jacks in correct order, added labelling to pins
2023-06-10 screenshot
2023-06-10 screenies + jlcpcb placeholders
2023-06-13 updated files
2023-06-19 updated..
2023-06-20 before changing midi footprints
2023-06-21 sent to jlcpcb
2023-06-22 tracked zips
2023-07-19 added readme with notes on what needs fixing
2023-07-23 warning not to use and link to project code
2023-08-04 updated README to document desired fixes/improvements!
2023-10-21 solve a couple of problems on main board + main panel
2023-10-26 fix user drawing line on wrong layer (user1, interpreted as vcut!!) causing rejection by jlcpcb!!
2023-10-26 fixed gerbers
2023-12-30 most of USB+SD card expander done
2023-12-30 added readme of todo's for the USD+SD expander
2023-12-30 improved schematic layout a little
2024-01-13 updated to correct(?) footprint + 3d model for the usb socket
2024-01-13 update labling
2024-02-10 fucking connect the USB Host pins that were completely unconnected previously... facepalm!
2024-02-10 flip headers back to correct side of board
2024-02-11 some improved routing
2024-07-02 fixed yet more dumb routing errors on the usb_sd; probably still isn't ready to use
2024-07-14 believe fixed problems with expander_usb_sd; tracked a bunch of stuff that was untracked (expander_cv_output?)
2024-08-18 swap accidentally flipped resistors on outputs 13+14
2024-08-18 moved track to eliminate a DRC error
2024-08-19 updated readme notes
2024-12-29 tracked first draft of expander_cv_output
2024-12-29 fixed incorrectly reversed analog input pins *facepalm*
2024-12-31 removed some redundant traces
