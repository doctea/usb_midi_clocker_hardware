# Repository doctea/usb_midi_clocker_hardware

File README.md:

*IMPORTANT: DO NOT USE THESE FOR ANYTHING YET, THEY ARE VERY MUCH PROTOTYPES AND HAVE SOME PROBLEMS!!!!*

Files for PCB modules for use by [usb_midi_clocker](https://github.com/doctea/usb_midi_clocker/) project.

# Todo

## General

- IMPROVE: reduce size of jack holes to make a snugger fit with less wobble?
- IMPROVE: Some nice panel graphics!

## Main module

### Main module board

- DONE: FIX: Replace the voltage regulator with one that will actually be able to deliver enough amps to power the screen and Teensy *facepalm*
 - ~~Can work around this for the moment by connecting directly to 5v Eurorack power with eg Dupont cables~~
- FIX: Fix/bridge/remove power diode that prevents power from USB going to screen
- IMPROVE: Make the i2c port into a 2x5 connector
- IMPROVE: Add 100ohm resistors on the SPI connectors

### Main module panel

- DONE: IMPROVE: Cutout for display pins in order to allow the panel to sit flat on top of the display without bending like it currently does?
- DONE/UNTESTED: FIX: Make the encoder hole bigger, so that the encoder will fit through

## Gate expander

### Gate expander back board

- FIX: ?? fix whatever the problem is that is making SPI unreliable af and lights randomly seeming to not go off
- DONE/UNTESTED: one of the protection diodes isn't connected to ground
- FIX: eratic behaviour where LEDs stay lit, don't light up properly, etc
	- seems to be fixed/worked around by dropping SPI rate and putting a 22pf cap between MOSI+GND, one between GND+CS1, on between GND+SCK, one between CS1+SCK, and a 100ohm resistor between CS1+SCK too
- FIX: when put into 'inputs' mode, all seem to read HIGH when there isn't anything connected?
- FIX: when put into 'inputs' mode, two of the SEQUENCER channels randomly flicker on/off...?
- FIX: the switch pins currently connect tip to ground; should this go through a large resistor to act as a pull-down?  or not happen at all?
- FIX: layout of the 'sequencer' outputs isn't right, for unknown reasons? (worked around in software)

### Gate expander jacks board

- FIX/UNTESTED: outputs 13+14 had their resistor values accidentally swapped - 1k <-> 47k!

### Gate expander panel

- IMPROVE: make reversible in / out, or label as CLOCK / SEQUENCER

## CV Input expander

### CV Input board

- IMPROVE: make header 2x5 instead of 2x4?

## MIDI expander

- Seems to be working on first attempt!
- IMPROVE: pitch spacing of the resistors/capacitors to allow common components to fit a little better (slightly wider resistor spacing, slightly narrower capacitor spacing)
- IMPROVE: maybe add protection diodes to protect the Teensy's GPIO pins in the event of wrong thing being connected?
- IMPROVE: Make panel double-sided (in+outs 1-4 on one side, 5-6 on the other)
- IMPROVE: probably possible to do this in 3hp instead of 4hp

## USB+SD expander

- TODO: Add a way to directly power USB Host from case's 5V
- TODO: IMPORTANT! Label the USB Host pins so that can tell which end is ground!

## CV Output expander

- DONE: correct the ADC inputs, as they are reversed on the first boards! (A was connected to C and C was connected to A) *facepalm*
- FIX: find correct footprint/component to use for the +12/-12v protection diodes (workaround is to just bridge the connections -- remember to do this BEFORE spending 6 hours debugging everything else!!  Without this, it will look like the DAC chip is working except you won't get any output at all!!!)
- IMPROVE: move the power connector to the inside edge of the board and use right-angle pin headers 
- IMPROVE: use right-angle pin headers/socket for the expander port; maybe get rid of one of the duplicate expander port to give more room for the power connector
- IMPROVE: label the stripe on the expander port(s)

### Addresses

| Address | A1  | A0  | Note |
| ------- | --- | --- | ---- |
|  0x4C   | LOW | LOW | correct |
|  0x4D   | LOW | HIGH | incorrectly seems to stick at 0x4C as if A0 is stuck low? |
|  0x4E   | HIGH | LOW | correct |
|  0x4F   | HIGH | HIGH | untested - presumed non-working as A0 seems to be stuck low in this hardware revision? |

| Bank | A3 | A2 | Note |
| ---- | -- | -- | ---- |
| 0    | LOW | LOW | Correct |
| 1    | LOW | HIGH | Correct |
| 2    | HIGH | LOW | untested but presumed working |
| 3    | HIGH | HIGH | untested but presumed working |

# Future

- Daughterboards to replace the CV input (currently reliant on Pimoroni 24v ADC module):
 - Own replacement for the Pimoroni board (believe this to be beyond my current ability)
 - Daughterboard to add 3xGate outputs, instead of inputs, based around a GPIO i2c
- Expander-for-the-expander to add switches to select uni-polar/bipolar modes -- with GPIO i2c on there, too, so that we know in software to switch modes and use different calibration data

## KiCad design expander_cv_output/expander_cv_output/expander_cv_output.kicad_pcb

File expander_cv_output/expander_cv_output/readme.md:

https://www.falstad.com/circuit/circuitjs.html?ctz=CQAgjCAMB0l3BWEA2aAWB8CcBmSy0AOBBAdkJDMsskoFMBaMMAKADcQGcAmEbwil15ZkUcCDS1u0JNKS0YCFgHNOPPgLW8cOUQpYAnLSBEo0JveHiGzF8FmGXu3OCwDu93mGS0wDvpAUkO62pgTgPlAh4d60Mf7BHuHO5smkvMEAhrYuFH68uSB5vExe8PAgONA4fliEWGjcCMiEyG2EpJXVZeXBAPKVugEUaN7D4sFg6eD8fM3jTZadYNAEvetwEDgTUDIgAEIAlpkAziAAgiwAyjnTYLPc074gAGaZADYndGLcLFNeD00hX4QRAnSq6nMCl2SCOpwONnyC0k4ykLhCSNMSNiUSS5hxWMiiU8EV8kRxwQAxnxpsDaU9wLANhswIxlopSHBkFhSOkyNw0KR5EzWKpHgV6doXGIqXYcfKiXxoLUsKq1erVYRGMxOKRoE00DwcFhIM0EMQSLtNiFxcipIEokZbcwJV5SE5yioaV57t7bPp-pxwkROC6JKDlvqkPIZXsACLnADCfBstsKOlEhV81gA9mJwrRJHVqDBIE0xNtaNttCw81h-TNuCarKtuDgBPdIDUEGhTKXNuJWEA

https://www.falstad.com/circuit/circuitjs.html?ctz=CQAgjCAMB0l3BWEA2aAWB8CcBmSy0AOBBAdkJDMsskoFMBaMMAKADcQGcAmEbwil15ZkUcCDS1u0JNKS0YCFgHNOPPgLW8cOUQpYAnLSBEo0JveHiGzF8FmGXu3OCwDu93mGS0wDvpAUkO62pgTgPlAh4d60Mf7BHuHO5smkvMEAhrYuFH68uSB5vExe8PAgONA85TqBpGCYWJXVZeXBAPJmUoEg6T15UWDp4Px8CKKF3BNipODQBO1LcBA44goyIABCAJaZAM4gAIIsAMo5I2Bj3CO+IABmmQA2+3Ri3CzDXteaU5q0cyq6nMCigm12B22NnyAQo3EksPeLhCMNMMNiUSS5gxaMiiU8EV8kQxwQAxpRSJNemRJrd5ssGWBGHMGDBuMhiJB4cNIKQ0DoENMwSsVBTabwaZUXGIyXYMfK8XxoH4sKq1eq1YRGMwWshMIQGoQcFhCGhJKQ1jARR5JYUEGbEcEjJLmBLKeB3T1rKoXVcxbZ9F9OOEiJxXRIgn15kL5DLNgARI4AYT4NltvUWjqsrmyNT4IzQ3nzwnASCYSDAS04bI5RAQOEI7O4fl0ghrnO5pF5-Jwgor7RC8IGUuH+Lz01E496wW8vH5BRmaGSM14ABM6I8AK5PAAuDCedFX6zjkFYs4kyU0840cJA663u-3h7EEA2p5ChfFEnUE8xEiLNxzj+-wfsuohLuY-BBKB5g6JO0pwX+46aHmiFOiOlS6Bhn4vt62FFnmEEyiEU4UPakHTjBN4XrBWH4pmhSZlc0GqP04B+mxpj6OcTFjGxzEyg8zyvO8LAAPZiOEtCSCa1BWkKtCWpUfCVOJJgBqM3BYL4MBoOQqrcDwXY4HpeiwCs4hrDgr6VKsLBAA

Board: 2 copper layers, 86.1 x 128.5 mm, 76 parts (4 on the bottom side), 59 nets.

Parts:
ADDR_A0, ADDR_A1, ADDR_A2, ADDR_A3: Conn_01x03_Pin; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
ADS1015_2_DIG1: ADS1015 digital side; PinSocket_1x05_P2.54mm_Vertical
ASD1015_2_ANA1: ADS1015 analog side; PinSocket_1x05_P2.54mm_Vertical
C1, C2, C5, C6, C7, C9, C12, C13, C16, C17, C18, C19: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4: 10uF; CP_Elec_5x5.7
C8: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10, C11, C14, C15: 22pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2: 1N5817; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
DAC1: DAC8574IPWG4; TSSOP-16_4.4x5mm_P0.65mm
EURO_POWER1: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Vertical
J2, J7: Conn_02x05_Odd_Even; IDC-Header_2x05_P2.54mm_Vertical
J3: SDA pullup; PinHeader_1x02_P2.54mm_Vertical
J4: SCL pullup; PinHeader_1x02_P2.54mm_Vertical
J5: Conn_02x08_Counter_Clockwise; PinHeader_2x08_P2.54mm_Vertical
JACK_A1, JACK_A2: PJ302M
JACK_B1, JACK_B2: PJ302M
JACK_C1, JACK_C2: PJ302M
JACK_D1: PJ302M
LED_A1: LED_Dual_Bidirectional; LED_D3.0mm
LED_B1: LED_Dual_Bidirectional; LED_D3.0mm
LED_C1: LED_Dual_Bidirectional; LED_D3.0mm
LED_D1: LED_Dual_Bidirectional; LED_D3.0mm
R1, R5, R6: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 560; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4: 150r; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R8, R13, R14, R17, R18, R23, R24: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9, R10, R19, R20: 2.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11, R12, R21, R22: 220; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15, R16, R25, R26: 47; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1, U2: TL074; SOIC-14_3.9x8.7mm_P1.27mm
U3: LM4040DBZ-5; SOT-23_Handsoldering
U4: LD1117S33TR_SOT223; SOT-223
U5: LM4040DBZ-33; SOT-23_Handsoldering

Connections:
1.65v reference: J5.5, J5.6, J5.11, J5.12, R3.2, R4.1
3.3V: C8.2, C19.2, DAC1.12 (IOVDD), J3.1, J4.1, J5.16, U4.2 (VO)
3.3v reference: J5.1, J5.2, J5.7, J5.8, R2.2, R3.1, U5.1 (K)
5V: ADDR_A0.3, ADDR_A1.3, ADDR_A2.3, ADDR_A3.3, ADS1015_2_DIG1.1, ASD1015_2_ANA1.1, C7.2, C9.2, C18.2, DAC1.4 (VDD), EURO_POWER1.11, EURO_POWER1.12, J5.15, U4.3 (VI)
5v reference: DAC1.3 (VREFH), R1.2, U3.1 (K)
12V: C1.1, C2.1, C4.1, D2.1 (K), R1.1, R2.1, U1.4 (V+), U2.4 (V+)
+5V from Host: J2.6, J2.8, J7.6, J7.8
-12V: C3.2, C5.2, C6.1, D1.2 (A), U1.11 (V-), U2.11 (V-)
CV GND: ADDR_A0.1, ADDR_A1.1, ADDR_A2.1, ADDR_A3.1, ADS1015_2_DIG1.5, ASD1015_2_ANA1.5, C1.2, C2.2, C3.1, C4.2, C5.1, C6.2, C7.1, C8.1, C9.1, C12.1, C13.1, C16.1, C17.1, C18.1, C19.1, DAC1.5 (VREFL), DAC1.6 (GND), DAC1.9 (LDAC), EURO_POWER1.3, EURO_POWER1.4, EURO_POWER1.5, EURO_POWER1.6, EURO_POWER1.7, EURO_POWER1.8, J2.2, J2.4, J5.13, J5.14, J7.2, J7.4, JACK_A1.1, JACK_A2.1, JACK_B1.1, JACK_B2.1, JACK_C1.1, JACK_C2.1, JACK_D1.1, R4.2, R13.1, R14.1, R23.1, R24.1, U3.2 (A), U4.1 (GND), U5.2 (A)
DAC 1 Bias: J5.3, U1.3 (+)
DAC 2 Bias: J5.9, U1.5 (+)
DAC 3 Bias: J5.4, U2.3 (+)
DAC 4 Bias: J5.10, U2.5 (+)
DAC output 1: DAC1.1 (VOUTA), R7.1
DAC output 2: DAC1.2 (VOUTB), R8.1
DAC output 3: DAC1.7 (VOUTC), R17.1
DAC output 4: DAC1.8 (VOUTD), R18.1
Input Frontboard A: ASD1015_2_ANA1.4, JACK_A2.3
Input Frontboard B: ASD1015_2_ANA1.3, JACK_B2.3
Input Frontboard C: ASD1015_2_ANA1.2, JACK_C2.3
unnamed: ADDR_A0.2, DAC1.13 (A0)
unnamed: ADDR_A1.2, DAC1.14 (A1)
unnamed: ADDR_A2.2, DAC1.15 (A2)
unnamed: ADDR_A3.2, DAC1.16 (A3)
unnamed: C10.2, R9.2, R11.1, U1.1
unnamed: C11.2, R10.2, R12.1, U1.7
unnamed: C14.2, R19.2, R21.1, U2.1
unnamed: C15.2, R20.2, R22.1, U2.7
unnamed: D1.1 (K), EURO_POWER1.1, EURO_POWER1.2
unnamed: D2.2 (A), EURO_POWER1.9, EURO_POWER1.10
unnamed: J2.9, J7.9
unnamed: J2.10, J7.10
unnamed: J3.2, R5.1
unnamed: J4.2, R6.1
unnamed: C10.1, R7.2, R9.1, U1.2 (-)
unnamed: C11.1, R8.2, R10.1, U1.6 (-)
unnamed: C12.2, R11.2, R15.1, U1.10 (+)
unnamed: C13.2, R12.2, R16.1, U1.12 (+)
unnamed: C14.1, R17.2, R19.1, U2.2 (-)
unnamed: C15.1, R18.2, R20.1, U2.6 (-)
unnamed: C16.2, R21.2, R25.1, U2.10 (+)
unnamed: C17.2, R22.2, R26.1, U2.12 (+)
Normal A: JACK_A1.2, JACK_A2.2
Normal B: JACK_B1.2, JACK_B2.2
Normal C: JACK_C1.2, JACK_C2.2
Out A LED Backboard: LED_A1.1 (KA), U1.8
Out A LED Return Backboard: LED_A1.2 (AK), R13.2, U1.9 (-)
Out B LED Backboard: LED_B1.1 (KA), U1.14
Out B LED Return Backboard: LED_B1.2 (AK), R14.2, U1.13 (-)
Out C LED Backboard: LED_C1.1 (KA), U2.8
Out C LED Return Backboard: LED_C1.2 (AK), R23.2, U2.9 (-)
Out D LED Backboard: LED_D1.1 (KA), U2.14
Out D LED Return Backboard: LED_D1.2 (AK), R24.2, U2.13 (-)
Output Backboard A: JACK_A1.3, R15.2
Output Backboard B: JACK_B1.3, R16.2
Output Backboard C: JACK_C1.3, R25.2
Output Backboard D: JACK_D1.3, R26.2
i2c SCL: ADS1015_2_DIG1.3, DAC1.10 (SCL), J2.1, J2.5, J7.1, J7.5, R6.2
i2c SDA: ADS1015_2_DIG1.2, DAC1.11 (SDA), J2.3, J2.7, J7.3, J7.7, R5.2

File expander_cv_output/expander_cv_output/production-board/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"ADDR_A0, ADDR_A1, ADDR_A2, ADDR_A3",SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm,4,Conn_01x03_Pin,
ADS1015_2_DIG1,PinSocket_1x05_P2.54mm_Vertical,1,ADS1015 digital side,
ASD1015_2_ANA1,PinSocket_1x05_P2.54mm_Vertical,1,ADS1015 analog side,
"C1, C12, C13, C16, C17, C18, C19, C2, C5, C6, C7, C9",0805,12,100nF,
"C10, C11, C14, C15",0805,4,22pF,
"C3, C4",CP_Elec_5x5.7,2,C_Polarized_Small,
C8,0805,1,10uF,
D1,0805,1,D,
D2,0805,1,D_Small,
DAC1,TSSOP-16_4.4x5mm_P0.65mm,1,DAC8574IPWG4,
EURO_POWER1,PinHeader_2x08_P2.54mm_Vertical,1,Conn_02x08_Odd_Even,
"J2, J7",IDC-Header_2x05_P2.54mm_Vertical,2,Conn_02x05_Odd_Even,
J3,PinHeader_1x02_P2.54mm_Vertical,1,SDA pullup,
J4,PinHeader_1x02_P2.54mm_Vertical,1,SCL pullup,
J5,PinHeader_2x08_P2.54mm_Vertical,1,Conn_02x08_Counter_Clockwise,
"JACK_A1, JACK_A2, JACK_B1, JACK_B2, JACK_C1, JACK_C2, JACK_D1",PJ302M,7,PJ302M,
"LED_A1, LED_B1, LED_C1, LED_D1",LED_D3.0mm,4,LED_Dual_Bidirectional,
"R1, R5, R6",0805,3,10k,
"R10, R19, R20, R9",0805,4,2.2k,
"R11, R12, R21, R22",0805,4,220,
"R13, R14, R17, R18, R23, R24, R7, R8",0805,8,1K,
"R15, R16, R25, R26",0805,4,47,
R2,0805,1,560,
"R3, R4",0805,2,150r,
"U1, U2",SOIC-14_3.9x8.7mm_P1.27mm,2,TL074,
U3,SOT-23_Handsoldering,1,LM4040DBZ-5,
U4,SOT-23_Handsoldering,1,LD1117S33TR_SOT223,
U5,SOT-23_Handsoldering,1,LM4040DBZ-33,

## KiCad design expander_gate_output/expander_gate_output.kicad_pcb

Board: 2 copper layers, 140.0 x 128.5 mm, 116 parts (10 on the bottom side), 96 nets.

Parts:
C1, C2, C5, C6, C7: C_Small; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40: BAT43; D_SOD-123
D17, D18, D19, D20, D21, D22, D23, D24, D41, D42, D43, D44, D45, D46, D47, D48: LED; LED_D3.0mm
EXPANDER_THRU: 16 pin header; PinHeader_2x08_P2.54mm_Vertical
GATE_SPI_OUTPUT_EXPANDER1: 16 pin header; PinHeader_2x08_P2.54mm_Vertical
J1: Output_A_Connector_Backboard; PinSocket_1x10_P2.54mm_Vertical
J2: Output_B_Connector_Backboard; PinSocket_1x10_P2.54mm_Vertical
J3: Output_A_Connector_Frontboard; PinHeader_1x10_P2.54mm_Vertical
J4: Output_B_Connector_Frontboard; PinHeader_1x10_P2.54mm_Vertical
J5: Eurorack power; IDC-Header_2x08_P2.54mm_Vertical
J6: CS_SELECT; PinHeader_1x03_P2.54mm_Vertical
J7: 5V selector; PinHeader_1x03_P2.54mm_Vertical
J16: ADDR0; PinHeader_1x03_P2.54mm_Vertical
J17: ADDR1; PinHeader_1x03_P2.54mm_Vertical
J18: ADDR2; PinHeader_1x03_P2.54mm_Vertical
JACK1, JACK14: Thonkiconn Renumbered
JACK2, JACK3, JACK4, JACK5, JACK6, JACK7, JACK8, JACK9, JACK10, JACK11, JACK12, JACK13, JACK15, JACK16: fuzzySI_thonkiconn; Thonkiconn Renumbered
R1, R3, R5, R7, R9, R11, R13, R15, R17, R19, R21, R23, R25, R27, R29, R31: 47K; R_0805_2012Metric
R2, R4, R6, R8, R10, R12, R14, R16, R18, R20, R22, R24, R26, R28, R30, R32: 1K; R_0805_2012Metric
U1, U2: TXS0108EPW; TSSOP-20_4.4x6.5mm_P0.65mm
U3: MCP23S17_SS; SSOP-28_5.3x10.2mm_P0.65mm

Connections:
+3V3: C1.2, C6.2, EXPANDER_THRU.10, EXPANDER_THRU.12, GATE_SPI_OUTPUT_EXPANDER1.10, GATE_SPI_OUTPUT_EXPANDER1.12, U1.2 (VCCA), U1.10 (OE), U2.2 (VCCA), U2.10 (OE)
+5V: C2.1, C5.2, C7.1, D1.1 (K), D3.1 (K), D5.1 (K), D7.1 (K), D9.1 (K), D11.1 (K), D13.1 (K), D15.1 (K), D26.1 (K), D28.1 (K), D29.1 (K), D31.1 (K), D33.1 (K), D35.1 (K), D37.1 (K), D39.1 (K), EXPANDER_THRU.6, EXPANDER_THRU.8, J7.2, J16.1, J17.1, J18.1, U1.19 (VCCB), U2.19 (VCCB), U3.9 (VDD), U3.18 (~RESET)
+5V from Eurorack: J5.11, J5.12, J7.3
+5V from main: GATE_SPI_OUTPUT_EXPANDER1.6, GATE_SPI_OUTPUT_EXPANDER1.8, J7.1
A0: J16.2, U3.15 (A0)
A1: J17.2, U3.16 (A1)
A2: J18.2, U3.17 (A2)
CS_1: EXPANDER_THRU.5, GATE_SPI_OUTPUT_EXPANDER1.5, J6.1
CS_2: EXPANDER_THRU.7, GATE_SPI_OUTPUT_EXPANDER1.7, J6.3
CS_INPUT: J6.2, U3.11 (~CS)
GATE_1: U1.9 (A8), U3.1 (GPB0)
GATE_2: U1.8 (A7), U3.2 (GPB1)
GATE_3: U1.7 (A6), U3.3 (GPB2)
GATE_4: U1.6 (A5), U3.4 (GPB3)
GATE_5: U1.5 (A4), U3.5 (GPB4)
GATE_6: U1.4 (A3), U3.6 (GPB5)
GATE_7: U1.3 (A2), U3.7 (GPB6)
GATE_8: U1.1 (A1), U3.8 (GPB7)
GATE_9: U2.9 (A8), U3.21 (GPA0)
GATE_10: U2.8 (A7), U3.22 (GPA1)
GATE_11: U2.7 (A6), U3.23 (GPA2)
GATE_12: U2.6 (A5), U3.24 (GPA3)
GATE_13: U2.5 (A4), U3.25 (GPA4)
GATE_14: U2.4 (A3), U3.26 (GPA5)
GATE_15: U2.3 (A2), U3.27 (GPA6)
GATE_16: U2.1 (A1), U3.28 (GPA7)
GND: C1.1, C2.2, C5.1, C6.1, C7.2, D2.2 (A), D4.2 (A), D6.2 (A), D8.2 (A), D10.2 (A), D12.2 (A), D14.2 (A), D16.2 (A), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.2 (A), D27.2 (A), D30.2 (A), D32.2 (A), D34.2 (A), D36.2 (A), D38.2 (A), D40.2 (A), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), EXPANDER_THRU.2, EXPANDER_THRU.4, GATE_SPI_OUTPUT_EXPANDER1.2, GATE_SPI_OUTPUT_EXPANDER1.4, J1.9, J1.10, J2.9, J2.10, J3.9, J3.10, J4.9, J4.10, J5.3, J5.4, J5.5, J5.6, J5.7, J5.8, J16.3, J17.3, J18.3, JACK1.1, JACK1.2, JACK2.1, JACK2.2, JACK3.1, JACK3.2, JACK4.1, JACK4.2, JACK5.1, JACK6.1, JACK6.2, JACK7.1, JACK7.2, JACK8.1, JACK8.2, JACK9.1, JACK9.2, JACK10.1, JACK10.2, JACK11.1, JACK12.1, JACK12.2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
INT_1: EXPANDER_THRU.15, GATE_SPI_OUTPUT_EXPANDER1.15, U3.20 (INTA)
INT_2: EXPANDER_THRU.13, GATE_SPI_OUTPUT_EXPANDER1.13, U3.19 (INTB)
MISO: EXPANDER_THRU.3, GATE_SPI_OUTPUT_EXPANDER1.3, U3.14 (SO)
MOSI: EXPANDER_THRU.1, GATE_SPI_OUTPUT_EXPANDER1.1, U3.13 (SI)
unnamed: D17.2 (A), R1.1
unnamed: D18.2 (A), R3.1
unnamed: D19.2 (A), R5.1
unnamed: D20.2 (A), R7.1
unnamed: D21.2 (A), R9.1
unnamed: D22.2 (A), R11.1
unnamed: D23.2 (A), R13.1
unnamed: D24.2 (A), R15.1
unnamed: D41.2 (A), R17.1
unnamed: D42.2 (A), R19.1
unnamed: D43.2 (A), R21.1
unnamed: D44.2 (A), R23.1
unnamed: D45.2 (A), R25.1
unnamed: D46.2 (A), R27.1
unnamed: D47.2 (A), R29.1
unnamed: D48.2 (A), R31.1
unnamed: JACK1.3, R12.1
unnamed: JACK2.3, R8.1
unnamed: JACK3.3, R4.1
unnamed: JACK4.3, R10.1
unnamed: JACK5.3, R6.1
unnamed: JACK6.3, R2.1
unnamed: JACK7.3, R14.1
unnamed: JACK8.3, R16.1
unnamed: JACK9.3, R18.1
unnamed: JACK10.3, R20.1
unnamed: JACK11.3, R22.1
unnamed: JACK12.3, R24.1
unnamed: JACK13.3, R26.1
unnamed: JACK14.3, R28.1
unnamed: JACK15.3, R30.1
unnamed: JACK16.3, R32.1
SCK: EXPANDER_THRU.9, GATE_SPI_OUTPUT_EXPANDER1.9, U3.12 (SCK)
output_1_backboard: D11.2 (A), D12.1 (K), J1.1, U1.20 (B1)
output_1_frontboard: J3.1, R11.2, R12.2
output_2_backboard: D7.2 (A), D8.1 (K), J1.2, U1.18 (B2)
output_2_frontboard: J3.2, R7.2, R8.2
output_3_backboard: D3.2 (A), D4.1 (K), J1.3, U1.17 (B3)
output_3_frontboard: J3.3, R3.2, R4.2
output_4_backboard: D9.2 (A), D10.1 (K), J1.4, U1.16 (B4)
output_4_frontboard: J3.4, R9.2, R10.2
output_5_backboard: D5.2 (A), D6.1 (K), J1.5, U1.15 (B5)
output_5_frontboard: J3.5, R5.2, R6.2
output_6_backboard: D1.2 (A), D2.1 (K), J1.6, U1.14 (B6)
output_6_frontboard: J3.6, R1.2, R2.2
output_7_backboard: D13.2 (A), D14.1 (K), J1.7, U1.13 (B7)
output_7_frontboard: J3.7, R13.2, R14.2
output_8_backboard: D15.2 (A), D16.1 (K), J1.8, U1.12 (B8)
output_8_frontboard: J3.8, R15.2, R16.2
output_9_backboard: D39.2 (A), D40.1 (K), J2.8, U2.20 (B1)
output_9_frontboard: J4.8, R27.2, R28.2
output_10_backboard: D35.2 (A), D36.1 (K), J2.7, U2.18 (B2)
output_10_frontboard: J4.7, R23.2, R24.2
output_11_backboard: D31.2 (A), D32.1 (K), J2.6, U2.17 (B3)
output_11_frontboard: J4.6, R19.2, R20.2
output_12_backboard: D37.2 (A), D38.1 (K), J2.5, U2.16 (B4)
output_12_frontboard: J4.5, R25.2, R26.2
output_13_backboard: D33.2 (A), D34.1 (K), J2.4, U2.15 (B5)
output_13_frontboard: J4.4, R21.2, R22.2
output_14_backboard: D29.2 (A), D30.1 (K), J2.3, U2.14 (B6)
output_14_frontboard: J4.3, R17.2, R18.2
output_15_backboard: D27.1 (K), D28.2 (A), J2.2, U2.13 (B7)
output_15_frontboard: J4.2, R29.2, R30.2
output_16_backboard: D25.1 (K), D26.2 (A), J2.1, U2.12 (B8)
output_16_frontboard: J4.1, R31.2, R32.2

File expander_gate_output/expander_gates_back_board gerbers/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C5, C6, C7",0805,5,C_Small,
"D1, D10, D11, D12, D13, D14, D15, D16, D2, D25, D26, D27, D28, D29, D3, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D4, D40, D5, D6, D7, D8, D9",D_SOD-123,32,BAT43,
"EXPANDER_THRU, GATE_SPI_OUTPUT_EXPANDER1",PinHeader_2x08_P2.54mm_Vertical,2,16 pin header,
J1,PinSocket_1x10_P2.54mm_Vertical,1,Output_A_Connector_Backboard,
J16,PinHeader_1x03_P2.54mm_Vertical,1,ADDR0,
J17,PinHeader_1x03_P2.54mm_Vertical,1,ADDR1,
J18,PinHeader_1x03_P2.54mm_Vertical,1,ADDR2,
J2,PinSocket_1x10_P2.54mm_Vertical,1,Output_B_Connector_Backboard,
J5,IDC-Header_2x08_P2.54mm_Vertical,1,Eurorack power,
J6,PinHeader_1x03_P2.54mm_Vertical,1,CS_SELECT,
J7,PinHeader_1x03_P2.54mm_Vertical,1,5V selector,
"U1, U2",TSSOP-20_4.4x6.5mm_P0.65mm,2,TXS0108EPW,
U3,SSOP-28_5.3x10.2mm_P0.65mm,1,MCP23S17_SS,

## KiCad design expander_usb_sd/expander_usb_sd.kicad_pcb

File expander_usb_sd/README.md:

#TODO

- DONE check measurements of the USB C screw-holes
- DONE check measurements of cutout for the SD card holder
- DONEish arrange silkscreen text so purpose of each connector is properly usable

Parts:
External_USB_A_Host1: USB_A; ONSHORE_USB-A1VSB6; PARTREV D
H1, H2: MountingHole; MountingHole_3.2mm_M3
J1: Micro_SD_Card_Det1; PJS008U-3000-0
J1-TeensyPower1: USB power - Teensy device; PinHeader_1x02_P2.54mm_Vertical
J2: Internal_USB_Host_Teensy; PinHeader_1x05_P2.54mm_Vertical
J5-TeensyMicroUSB1: USB 5 pin to Teensy/MicroUSB; PinHeader_1x05_P2.54mm_Vertical
J6-USBHost1: USB 5 pin to frontpanel/Type C; PinHeader_1x05_P2.54mm_Vertical
SD_connector1: Conn_02x04_Odd_Even; PinHeader_2x04_P2.54mm_Vertical
USBHostPower1: USB power - host; PinHeader_1x02_P2.54mm_Vertical

Connections:
/CLK: J1.5 (CLK), SD_connector1.4
/CMD: J1.3 (CMD), SD_connector1.6
/DAT0: J1.7 (DAT0), SD_connector1.2
/DAT1: J1.8 (DAT1), SD_connector1.1
/DAT2: J1.1 (DAT2), SD_connector1.8
/DAT3: J1.2 (DAT3/CD), SD_connector1.7
/VCC: J1.4 (VDD), SD_connector1.5
GND: J1.6 (VSS), J1.10 (SHIELD), SD_connector1.3
unnamed: External_USB_A_Host1.3 (D+), J2.3
unnamed: External_USB_A_Host1.2 (D-), J2.2
unnamed: External_USB_A_Host1.4 (GND), External_USB_A_Host1.S1 (SHIELD), External_USB_A_Host1.S2 (SHIELD__1), J2.4, J2.5
unnamed: External_USB_A_Host1.1 (VBUS), USBHostPower1.2
unnamed: J1-TeensyPower1.1, J5-TeensyMicroUSB1.1
unnamed: J1-TeensyPower1.2, J6-USBHost1.1
unnamed: J2.1, USBHostPower1.1
unnamed: J5-TeensyMicroUSB1.2, J6-USBHost1.2
unnamed: J5-TeensyMicroUSB1.3, J6-USBHost1.3
unnamed: J5-TeensyMicroUSB1.4, J6-USBHost1.4
unnamed: J5-TeensyMicroUSB1.5, J6-USBHost1.5

Notes on the sheet:
USB Host connector
SD Card
USB Device connector

Board: 2 copper layers, 59.6 x 128.3 mm, 10 parts (5 on the bottom side), 19 nets.
