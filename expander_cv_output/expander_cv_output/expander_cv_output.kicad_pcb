# Repository doctea/usb_midi_clocker_hardware (continued)

## KiCad design usb_midi_clocker circuits.kicad_pcb

Board: 2 copper layers, 135.5 x 128.4 mm, 27 parts (23 on the bottom side), 54 nets.

Parts:
C3, C8: C_Small; C_Axial_L5.1mm_D3.1mm_P7.50mm_Horizontal
C5: C_Polarized_Small; CP_Radial_D6.3mm_P2.50mm
C6: 330nF; C_Axial_L5.1mm_D3.1mm_P7.50mm_Horizontal
C7: 100nF; C_Axial_L5.1mm_D3.1mm_P7.50mm_Horizontal
D1: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D+12V1: 1N5817; D_DO-41_SOD81_P10.16mm_Horizontal
GATE_OUTPUT_EXPANDER1: 16 pin header; PinHeader_2x08_P2.54mm_Vertical
I2C_EXPANDER: 8 pin header; PinHeader_2x04_P2.54mm_Vertical
J2: USB power; PinHeader_1x02_P2.54mm_Vertical
J4: USB Host header; PinHeader_1x05_P2.54mm_Vertical
J5: Conn_01x09_Pin; PinHeader_2x05_P2.54mm_Vertical
MIDI_EXPANDER_1, MIDI_EXPANDER_2: Conn_02x05_Counter_Clockwise; PinHeader_2x05_P2.54mm_Vertical
POWER1: Eurorack power header; IDC-Header_2x05_P2.54mm_Vertical
R1: 100R; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
R2, R3, R5, R6: R; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
R4: 100r; R_Axial_DIN0309_L9.0mm_D3.2mm_P2.54mm_Vertical
SW1: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
SW2: SW_Push_Back; SW_PUSH_6mm_H13mm
SW3: SW_Push_Select; SW_PUSH_6mm_H13mm
U2: Teensy4.1; Teensy41
U3: TFT_320x240; doctea ili9341 3.2
U4: L7805; TO-220-3_Vertical

Connections:
+3V3: GATE_OUTPUT_EXPANDER1.10, GATE_OUTPUT_EXPANDER1.12, J5.7, R2.2, R3.2, R4.1, R5.2, R6.2, U2.15 (3V3), U2.46 (3V3), U3.4 (RST)
+5V: C7.1, D1.2 (A), GATE_OUTPUT_EXPANDER1.6, GATE_OUTPUT_EXPANDER1.8, I2C_EXPANDER.6, I2C_EXPANDER.8, J5.6, MIDI_EXPANDER_1.5, MIDI_EXPANDER_2.5, R1.1, U4.3 (OUT)
+12V: C5.1, C6.1, D+12V1.1 (K), U4.1 (IN)
External CS1: GATE_OUTPUT_EXPANDER1.5, U2.30 (38_CS1_IN1)
External CS2: GATE_OUTPUT_EXPANDER1.7, U2.29 (37_CS)
GND: C3.2, C5.2, C6.2, C7.2, C8.1, GATE_OUTPUT_EXPANDER1.2, GATE_OUTPUT_EXPANDER1.4, I2C_EXPANDER.2, I2C_EXPANDER.4, J4.4, J4.5, J5.8, J5.9, MIDI_EXPANDER_1.6, MIDI_EXPANDER_2.6, POWER1.3, POWER1.4, POWER1.5, POWER1.6, POWER1.7, POWER1.8, SW1.C, SW1.S2, SW2.2, SW3.2, U2.1 (GND), U2.34 (GND), U2.47 (GND), U2.58 (GND), U2.59 (GND), U3.2 (GND), U4.2 (GND)
Gate SPI MISO: GATE_OUTPUT_EXPANDER1.3, U2.31 (39_MISO1_OUT1A)
Gate SPI MOSI: GATE_OUTPUT_EXPANDER1.1, U2.18 (26_A12_MOSI1)
Gate SPI SCK: GATE_OUTPUT_EXPANDER1.9, U2.19 (27_A13_SCK1)
INT_1: GATE_OUTPUT_EXPANDER1.15, U2.32 (40_A16)
INT_2: GATE_OUTPUT_EXPANDER1.13, U2.33 (41_A17)
MIDI_1_RX: MIDI_EXPANDER_1.1, U2.2 (0_RX1_CRX2_CS1)
MIDI_1_TX: MIDI_EXPANDER_1.2, U2.3 (1_TX1_CTX2_MISO1)
MIDI_2_RX: MIDI_EXPANDER_1.3, U2.9 (7_RX2_OUT1A)
MIDI_2_TX: MIDI_EXPANDER_1.4, U2.10 (8_TX2_IN1)
MIDI_3_RX: MIDI_EXPANDER_1.10, U2.37 (15_A1_RX3_SPDIF_IN)
MIDI_3_TX: MIDI_EXPANDER_1.9, U2.36 (14_A0_TX3_SPDIF_OUT)
MIDI_4_RX: MIDI_EXPANDER_1.8, U2.38 (16_A2_RX4_SCL1)
MIDI_4_TX: MIDI_EXPANDER_1.7, U2.39 (17_A3_TX4_SDA1)
MIDI_5_RX: MIDI_EXPANDER_2.1, U2.43 (21_A7_RX5_BCLK1)
MIDI_5_TX: MIDI_EXPANDER_2.2, U2.42 (20_A6_TX5_LRCLK1)
MIDI_6_RX: MIDI_EXPANDER_2.3, U2.17 (25_A11_RX6_SDA2)
MIDI_6_TX: MIDI_EXPANDER_2.4, U2.16 (24_A10_TX6_SCL2)
MIDI_7_RX: MIDI_EXPANDER_2.10, U2.20 (28_RX7)
MIDI_7_TX: MIDI_EXPANDER_2.9, U2.21 (29_TX7)
MIDI_8_RX: MIDI_EXPANDER_2.8, U2.26 (34_RX8)
MIDI_8_TX: MIDI_EXPANDER_2.7, U2.27 (35_TX8)
unnamed: C3.1, D1.1 (K), U2.48 (VIN)
unnamed: D+12V1.2 (A), POWER1.9, POWER1.10
unnamed: J2.1, U2.55 (5V)
unnamed: J2.2, J4.1
unnamed: J4.2, U2.56 (D-)
unnamed: J4.3, U2.57 (D+)
unnamed: POWER1.1, POWER1.2
unnamed: R2.1, SW1.B, U2.4 (2_OUT2)
unnamed: R3.1, SW1.A, U2.5 (3_LRCLK2)
unnamed: SW1.S1, U2.6 (4_BCLK2)
unnamed: SW2.1, U2.7 (5_IN2)
unnamed: SW3.1, U2.8 (6_OUT1D)
unnamed: R4.2, U3.8 (LED)
unnamed: C8.2, R1.2, U3.1 (VCC)
TFT CS: R5.1, U2.11 (9_OUT1C), U3.3 (CS)
TFT DC: U2.12 (10_CS_MQSR), U3.5 (DC)
TFT SPI MISO: U2.14 (12_MISO_MQSL), U3.9 (MISO), U3.13
TFT SPI MOSI: U2.13 (11_MOSI_CTX1), U3.6 (MOSI), U3.12
TFT SPI SCK: U2.35 (13_SCK_LED), U3.7 (SCK), U3.10
Touch CS: R6.1, U2.22 (30_CRX3), U3.11
Touch IRQ: U2.23 (31_CTX3), U3.14
i2c SCL: I2C_EXPANDER.1, I2C_EXPANDER.5, U2.41 (19_A5_SCL)
i2c SDA: I2C_EXPANDER.3, I2C_EXPANDER.7, U2.40 (18_A4_SDA)
unused_pin_23: J5.5, U2.45 (23_A9_CRX1_MCLK1)
unused_pin_32: J5.3, U2.24 (32_OUT1B)
unused_pin_33: J5.2, U2.25 (33_MCLK2)
unused_pin_36: J5.1, U2.28 (36_CS)

## KiCad design expander_cv_input/expander_cv_input.kicad_pcb

Parts:
ADS1015_1_DIG1, ADS1015_2_DIG1: ADS1015 digital side; PinSocket_1x05_P2.54mm_Vertical
ASD1015_1_ANA1, ASD1015_2_ANA1: ADS1015 analog side; PinSocket_1x05_P2.54mm_Vertical
C1, C2: 100n; C_Disc_D5.0mm_W2.5mm_P5.00mm
CV_INPUT_I2C_EXPANDER_MAIN1: 8 pin header; PinHeader_2x04_P2.54mm_Vertical
JACK1, JACK2, JACK3, JACK4, JACK5, JACK6: AudioJack2_SwitchT; Jack_3.5mm_QingPu_WQP-PJ398SM_Vertical_CircularHoles

Connections:
+5V: ADS1015_1_DIG1.1, ADS1015_2_DIG1.1, ASD1015_1_ANA1.1, ASD1015_2_ANA1.1, C1.2, C2.2; also elsewhere on the board
A0 input Frontboard: ASD1015_1_ANA1.2, JACK1.T
A1 input Frontboard: ASD1015_1_ANA1.3, JACK2.T
A2 input Frontboard: ASD1015_1_ANA1.4, JACK3.T
A3 input Frontboard: ASD1015_2_ANA1.2, JACK4.T
A4 input Frontboard: ASD1015_2_ANA1.3, JACK5.T
A5 input Frontboard: ASD1015_2_ANA1.4, JACK6.T
ADS 1 Interrupt: ADS1015_1_DIG1.4
ADS 2 Interrupt: ADS1015_2_DIG1.4
CV GND: ADS1015_1_DIG1.5, ADS1015_2_DIG1.5, ASD1015_1_ANA1.5, ASD1015_2_ANA1.5, C1.1, C2.1, JACK1.S, JACK1.TN, JACK2.S, JACK2.TN, JACK3.S, JACK3.TN, JACK4.S, JACK4.TN, JACK5.S, JACK5.TN, JACK6.S, JACK6.TN; also elsewhere on the board
i2c SCL: ADS1015_1_DIG1.3, ADS1015_2_DIG1.3; also elsewhere on the board
i2c SDA: ADS1015_1_DIG1.2, ADS1015_2_DIG1.2; also elsewhere on the board

Board: 2 copper layers, 61.8 x 128.5 mm, 14 parts (8 on the bottom side), 10 nets.

Other parts of the board:
CV_INPUT_I2C_EXPANDER1, CV_INPUT_I2C_THRU1: 8 pin header; PinHeader_2x04_P2.54mm_Vertical

Their connections:
+5V: CV_INPUT_I2C_EXPANDER1.6, CV_INPUT_I2C_EXPANDER1.8, CV_INPUT_I2C_THRU1.6, CV_INPUT_I2C_THRU1.8; also elsewhere on the board
CV GND: CV_INPUT_I2C_EXPANDER1.2, CV_INPUT_I2C_EXPANDER1.4, CV_INPUT_I2C_THRU1.2, CV_INPUT_I2C_THRU1.4; also elsewhere on the board
i2c SCL: CV_INPUT_I2C_EXPANDER1.1, CV_INPUT_I2C_EXPANDER1.5, CV_INPUT_I2C_THRU1.1, CV_INPUT_I2C_THRU1.5; also elsewhere on the board
i2c SDA: CV_INPUT_I2C_EXPANDER1.3, CV_INPUT_I2C_EXPANDER1.7, CV_INPUT_I2C_THRU1.3, CV_INPUT_I2C_THRU1.7; also elsewhere on the board

## KiCad design expander_midi/expander_midi.kicad_pcb

Parts:
C2, C3, C5: 100n; C_Axial_L5.1mm_D3.1mm_P7.50mm_Horizontal
C6, C7: 100nF; C_Axial_L5.1mm_D3.1mm_P7.50mm_Horizontal
J1_BACK1: Conn_02x06_Odd_Even; PinHeader_2x06_P2.54mm_Vertical
J1_FRONT1: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Vertical
J2_BACK1: Conn_01x06_Pin; PinHeader_1x06_P2.54mm_Vertical
J2_FRONT1: Conn_01x06_Socket; PinSocket_1x06_P2.54mm_Vertical
JMIDIIN1, JMIDIIN2, JMIDIIN3, JMIDIIN4: MIDI In Jack 3.5mm stereo jack; Jack_3.5mm_QingPu_WQP-PJ398SM_TRS_Vertical_CircularHoles
JMIDIOUT1, JMIDIOUT2, JMIDIOUT3, JMIDIOUT4: MIDI In Jack 3.5mm stereo jack; Jack_3.5mm_QingPu_WQP-PJ398SM_TRS_Vertical_CircularHoles
MIDI_EXPANDER_1: Conn_02x05_Counter_Clockwise; PinHeader_2x05_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8: 47R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9, R10, R11, R12, R15, R16, R17, R18: 220R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R13, R14, R19, R20: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: LD1117; SOT-223-3_TabPin2
ULPZWmidi1, ULPZWmidi2, ULPZWmidi3, ULPZWmidi4: HCPL-0631; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: J1_BACK1.11, J1_BACK1.12, J1_FRONT1.11, J1_FRONT1.12, J2_BACK1.6, J2_FRONT1.6, R1.2, R2.2, R3.2, R4.2, R13.1, R14.1, R19.1, R20.1, U1.2 (VO); also elsewhere on the board
+5V: C2.1, C3.1, C5.1, C6.1, MIDI_EXPANDER_1.5, U1.3 (VI), ULPZWmidi1.8 (VCC), ULPZWmidi2.8 (VCC), ULPZWmidi3.8 (VCC), ULPZWmidi4.8 (VCC); also elsewhere on the board
GND: C2.2, C3.2, C5.2, C6.2, J1_BACK1.1, J1_BACK1.2, J1_FRONT1.1, J1_FRONT1.2, J2_BACK1.1, J2_FRONT1.1, JMIDIIN1.S, JMIDIIN2.S, JMIDIIN3.S, JMIDIIN4.S, JMIDIOUT1.S, JMIDIOUT2.S, JMIDIOUT3.S, JMIDIOUT4.S, MIDI_EXPANDER_1.6, U1.1 (GND), ULPZWmidi1.5 (GND), ULPZWmidi2.5 (GND), ULPZWmidi3.5 (GND), ULPZWmidi4.5 (GND); also elsewhere on the board
MIDI_1_RX: MIDI_EXPANDER_1.1, R13.2, ULPZWmidi1.6 (VO2), ULPZWmidi1.7 (VO1)
MIDI_1_TX: J2_BACK1.2, MIDI_EXPANDER_1.2
MIDI_1_TX_FRONT: J2_FRONT1.2, R5.2
MIDI_2_RX: MIDI_EXPANDER_1.3, R20.2, ULPZWmidi4.6 (VO2), ULPZWmidi4.7 (VO1)
MIDI_2_TX: J2_BACK1.3, MIDI_EXPANDER_1.4
MIDI_2_TX_FRONT: J2_FRONT1.3, R6.2
MIDI_3_RX: MIDI_EXPANDER_1.10, R14.2, ULPZWmidi2.6 (VO2), ULPZWmidi2.7 (VO1)
MIDI_3_TX: J2_BACK1.4, MIDI_EXPANDER_1.9
MIDI_3_TX_FRONT: J2_FRONT1.4, R7.2
MIDI_4_RX: MIDI_EXPANDER_1.8, R19.2, ULPZWmidi3.6 (VO2), ULPZWmidi3.7 (VO1)
MIDI_4_TX: J2_BACK1.5, MIDI_EXPANDER_1.7
MIDI_4_TX_FRONT: J2_FRONT1.5, R8.2
MIDI_IN_R_1_BACK: J1_BACK1.3, R9.2, ULPZWmidi1.3 (C2)
MIDI_IN_R_1_FRONT: J1_FRONT1.3, JMIDIIN1.R
MIDI_IN_R_2_BACK: J1_BACK1.5, R17.2, ULPZWmidi4.3 (C2)
MIDI_IN_R_2_FRONT: J1_FRONT1.5, JMIDIIN4.R
MIDI_IN_R_3_BACK: J1_BACK1.7, R11.2, ULPZWmidi2.3 (C2)
MIDI_IN_R_3_FRONT: J1_FRONT1.7, JMIDIIN3.R
MIDI_IN_R_4_BACK: J1_BACK1.9, R15.2, ULPZWmidi3.3 (C2)
MIDI_IN_R_4_FRONT: J1_FRONT1.9, JMIDIIN2.R
MIDI_IN_T_1_BACK: J1_BACK1.4, R10.2, ULPZWmidi1.2 (C1)
MIDI_IN_T_1_FRONT: J1_FRONT1.4, JMIDIIN1.T
MIDI_IN_T_2_BACK: J1_BACK1.6, R18.2, ULPZWmidi4.2 (C1)
MIDI_IN_T_2_FRONT: J1_FRONT1.6, JMIDIIN4.T
MIDI_IN_T_3_BACK: J1_BACK1.8, R12.2, ULPZWmidi2.2 (C1)
MIDI_IN_T_3_FRONT: J1_FRONT1.8, JMIDIIN3.T
MIDI_IN_T_4_BACK: J1_BACK1.10, R16.2, ULPZWmidi3.2 (C1)
MIDI_IN_T_4_FRONT: J1_FRONT1.10, JMIDIIN2.T
unnamed: JMIDIOUT1.R, R1.1
unnamed: JMIDIOUT1.T, R5.1
unnamed: JMIDIOUT2.R, R2.1
unnamed: JMIDIOUT2.T, R6.1
unnamed: JMIDIOUT3.R, R3.1
unnamed: JMIDIOUT3.T, R7.1
unnamed: JMIDIOUT4.R, R4.1
unnamed: JMIDIOUT4.T, R8.1
unnamed: R9.1, ULPZWmidi1.1 (A1)
unnamed: R10.1, ULPZWmidi1.4 (A2)
unnamed: R11.1, ULPZWmidi2.1 (A1)
unnamed: R12.1, ULPZWmidi2.4 (A2)
unnamed: R15.1, ULPZWmidi3.1 (A1)
unnamed: R16.1, ULPZWmidi3.4 (A2)
unnamed: R17.1, ULPZWmidi4.1 (A1)
unnamed: R18.1, ULPZWmidi4.4 (A2)

Notes on the sheet:
thanks to LPZW for this clever MIDI TRS auto-sensing circuit if you re-use then please credit LPZW!

Board: 2 copper layers, 70.4 x 128.5 mm, 44 parts (21 on the bottom side), 47 nets.

Other parts of the board:
C1, C4: 100nF; C_Axial_L5.1mm_D3.1mm_P7.50mm_Horizontal

Their connections:
+3V3: C4.1; also elsewhere on the board
+5V: C1.1; also elsewhere on the board
GND: C1.2, C4.2; also elsewhere on the board

## KiCad design _backups/usb_midi_clocker circuits.kicad_pcb

Parts:
C3, C8: C_Small; C_Axial_L5.1mm_D3.1mm_P7.50mm_Horizontal
C5: C_Polarized_Small; CP_Radial_D6.3mm_P2.50mm
C6: 10uF; C_Axial_L5.1mm_D3.1mm_P7.50mm_Horizontal
C7: 1uF; C_Axial_L5.1mm_D3.1mm_P7.50mm_Horizontal
CV_INPUT_I2C_EXPANDER_MAIN1: 8 pin header; PinHeader_2x04_P2.54mm_Vertical
D1: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D+12V1: 1N5817; D_DO-41_SOD81_P10.16mm_Horizontal
GATE_OUTPUT_EXPANDER1: 16 pin header; PinHeader_2x08_P2.54mm_Vertical
J1: SD card breakout; PinHeader_2x04_P2.54mm_Vertical
J2: USB power; PinHeader_1x02_P2.54mm_Vertical
J3: PJS008U-3000-0
J4: USB Host header; PinHeader_1x05_P2.54mm_Vertical
MIDI_EXPANDER_MAIN1: 20 pin header; PinHeader_2x10_P2.54mm_Vertical
POWER1: Eurorack power header; IDC-Header_2x05_P2.54mm_Vertical
R1: 100R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
SW2: SW_Push_Back; SW_PUSH_6mm_H13mm
SW3: SW_Push_Select; SW_PUSH_6mm_H13mm
U1: L78L05_TO92; TO-92_Inline
U2: Teensy4.1; Teensy41
U3: TFT_320x240; TFT-320x240

Connections:
+3V3: GATE_OUTPUT_EXPANDER1.10, GATE_OUTPUT_EXPANDER1.12, MIDI_EXPANDER_MAIN1.12, U2.15 (3V3), U2.46 (3V3), U3.8 (LED)
+5V: C7.1, CV_INPUT_I2C_EXPANDER_MAIN1.6, CV_INPUT_I2C_EXPANDER_MAIN1.8, D1.2 (A), GATE_OUTPUT_EXPANDER1.6, GATE_OUTPUT_EXPANDER1.8, MIDI_EXPANDER_MAIN1.11, R1.1, U1.1 (VO)
+12V: C5.1, C6.1, D+12V1.1 (K), U1.3 (VI)
External CS1: GATE_OUTPUT_EXPANDER1.5, U2.30 (38_CS1_IN1)
External CS2: GATE_OUTPUT_EXPANDER1.7, U2.29 (37_CS)
GND: C3.2, C5.2, C6.2, C7.2, C8.1, CV_INPUT_I2C_EXPANDER_MAIN1.2, CV_INPUT_I2C_EXPANDER_MAIN1.4, GATE_OUTPUT_EXPANDER1.2, GATE_OUTPUT_EXPANDER1.4, J4.4, J4.5, MIDI_EXPANDER_MAIN1.9, MIDI_EXPANDER_MAIN1.10, POWER1.3, POWER1.4, POWER1.5, POWER1.6, POWER1.7, POWER1.8, SW1.C, SW1.S2, SW2.2, SW3.2, U1.2 (GND), U2.1 (GND), U2.34 (GND), U2.47 (GND), U2.58 (GND), U2.59 (GND), U3.2 (GND)
Gate SPI MISO: GATE_OUTPUT_EXPANDER1.3, U2.31 (39_MISO1_OUT1A)
Gate SPI MOSI: GATE_OUTPUT_EXPANDER1.1, U2.18 (26_A12_MOSI1)
Gate SPI SCK: GATE_OUTPUT_EXPANDER1.9, U2.19 (27_A13_SCK1)
INT_1: GATE_OUTPUT_EXPANDER1.15, U2.32 (40_A16)
INT_2: GATE_OUTPUT_EXPANDER1.13, U2.33 (41_A17)
MIDI_1_RX: MIDI_EXPANDER_MAIN1.1, U2.2 (0_RX1_CRX2_CS1)
MIDI_1_TX: MIDI_EXPANDER_MAIN1.2, U2.3 (1_TX1_CTX2_MISO1)
MIDI_2_RX: MIDI_EXPANDER_MAIN1.3, U2.9 (7_RX2_OUT1A)
MIDI_2_TX: MIDI_EXPANDER_MAIN1.4, U2.10 (8_TX2_IN1)
MIDI_3_RX: MIDI_EXPANDER_MAIN1.5, U2.37 (15_A1_RX3_SPDIF_IN)
MIDI_3_TX: MIDI_EXPANDER_MAIN1.6, U2.36 (14_A0_TX3_SPDIF_OUT)
MIDI_4_RX: MIDI_EXPANDER_MAIN1.7, U2.38 (16_A2_RX4_SCL1)
MIDI_4_TX: MIDI_EXPANDER_MAIN1.8, U2.39 (17_A3_TX4_SDA1)
MIDI_5_RX: MIDI_EXPANDER_MAIN1.20, U2.43 (21_A7_RX5_BCLK1)
MIDI_5_TX: MIDI_EXPANDER_MAIN1.19, U2.42 (20_A6_TX5_LRCLK1)
MIDI_6_RX: MIDI_EXPANDER_MAIN1.18, U2.17 (25_A11_RX6_SDA2)
MIDI_6_TX: MIDI_EXPANDER_MAIN1.17, U2.16 (24_A10_TX6_SCL2)
MIDI_7_RX: MIDI_EXPANDER_MAIN1.16, U2.20 (28_RX7)
MIDI_7_TX: MIDI_EXPANDER_MAIN1.15, U2.21 (29_TX7)
MIDI_8_RX: MIDI_EXPANDER_MAIN1.14, U2.26 (34_RX8)
MIDI_8_TX: MIDI_EXPANDER_MAIN1.13, U2.27 (35_TX8)
unnamed: C3.1, D1.1 (K), U2.48 (VIN)
unnamed: D+12V1.2 (A), POWER1.9, POWER1.10
unnamed: J1.1, J3.8 (DAT1)
unnamed: J1.2, J3.7 (DAT0)
unnamed: J1.3, J3.6 (VSS)
unnamed: J1.4, J3.5 (CLK)
unnamed: J1.5, J3.4 (VDD)
unnamed: J1.6, J3.3 (CMD)
unnamed: J1.7, J3.2 (CD/DAT3)
unnamed: J1.8, J3.1 (DAT2)
unnamed: J2.1, U2.55 (5V)
unnamed: J2.2, J4.1
unnamed: J4.2, U2.56 (D-)
unnamed: J4.3, U2.57 (D+)
unnamed: POWER1.1, POWER1.2
unnamed: SW1.B, U2.4 (2_OUT2)
unnamed: SW1.A, U2.5 (3_LRCLK2)
unnamed: SW1.S1, U2.6 (4_BCLK2)
unnamed: SW2.1, U2.7 (5_IN2)
unnamed: SW3.1, U2.8 (6_OUT1D)
unnamed: C8.2, R1.2, U3.1 (VCC)
TFT CS: U2.12 (10_CS_MQSR), U3.3 (CS)
TFT DC: U2.11 (9_OUT1C), U3.5 (DC)
TFT Reset: U2.23 (31_CTX3), U3.4 (RST)
TFT SPI MISO: U2.14 (12_MISO_MQSL), U3.9 (MISO), U3.13
TFT SPI MOSI: U2.13 (11_MOSI_CTX1), U3.6 (MOSI), U3.12
TFT SPI SCK: U2.35 (13_SCK_LED), U3.7 (SCK), U3.10
Touch CS: U2.22 (30_CRX3), U3.11
Touch IRQ: U2.44 (22_A8_CTX1), U3.14
i2c SCL: CV_INPUT_I2C_EXPANDER_MAIN1.1, CV_INPUT_I2C_EXPANDER_MAIN1.5, U2.41 (19_A5_SCL)
i2c SDA: CV_INPUT_I2C_EXPANDER_MAIN1.3, CV_INPUT_I2C_EXPANDER_MAIN1.7, U2.40 (18_A4_SDA)
